# Keil uVision project SpaceInvaders.uvproj, settings and files
target SpaceInvaders (ARM-ADS)
  device: LM4F120H5QR Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: SpaceInvaders
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c include: ..;..\..\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s Nokia5110.c random.s SpaceInvaders.c TExaS.c TM4C123GH6PM1.h tm4c123gh6pm.h ADC.c ADC.h Potentiometer.c Potentiometer.h pwm.c pwm.h temp.c temp.h port.c port.h uart_driver.c uart_driver.h dio.h dio.c ldr.c ldr.h
    ..//Drivers/: PORTF.c PORTF.h shapes.c
    ../Drivers/: TIMER2.c shapes.h TIMER2.h screen_draw.c checkMoving.h checkMoving.c
